# Keil uVision project Bayonet_STM32F10x.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bayonet_STM32F10x (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: Bayonet_Assert
  c include: .\Interfaces\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Interfaces
    ./Interfaces/Src/: Bayonet_ADC.c Bayonet_Delay.c Bayonet_DMA.c Bayonet_GPIO.c Bayonet_NVIC.c Bayonet_RCC.c Bayonet_SPI.c Bayonet_TIM.c Bayonet_UART.c Bayonet_Flash.c Bayonet_CAN.c Bayonet_IIC.c Bayonet_EXTI.c Bayonet_DAC.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
